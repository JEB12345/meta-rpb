inherit siteinfo

BASELIB = "lib${SITEINFO_BITS}"

